# Keil uVision project Project.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\FreeRTOSv10.4.1\FreeRTOS\FreeRTOS\Source\include;C:\FreeRTOSv10.4.1\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: C:\FreeRTOSv10.4.1\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Application
    ./: Startup.s msgQ.c
    ../: lcd_func.c
  group FreeRTOS
    C:/FreeRTOSv10.4.1/FreeRTOS/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/FreeRTOSv10.4.1/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/FreeRTOSv10.4.1/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
